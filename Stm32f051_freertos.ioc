# file: Stm32f051_freertos.ioc
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FREERTOS.HEAP_NUMBER=1
FREERTOS.Tasks01=defaultTask,24,128,StartDefaultTask,Default,NULL,Dynamic,NULL,NULL
Mcu.Family=STM32F0
Mcu.Name=STM32F051C8Tx
Mcu.Package=LQFP48
NVIC.TIM1_BRK_UP_TRG_COM_IRQn=true\:3\:0\:false\:false\:true\:false\:false\:true\:true
NVIC.TimeBase=TIM1_BRK_UP_TRG_COM_IRQn
NVIC.TimeBaseIP=TIM1
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=Makefile
VP_FREERTOS_VS_CMSIS_V2.Mode=CMSIS_V2
VP_SYS_VS_tim1.Mode=TIM1
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2022 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"
#include "cmsis_os2.h"
#include "UART.h"
#include "application.h"

/* Definitions for defaultTask */
osThreadId_t defaultTaskHandle;
const osThreadAttr_t defaultTask_attributes = {
  .name = "defaultTask",
  .stack_size = 128 * 4,
  .priority = (osPriority_t) osPriorityNormal,
};

void SystemClock_Config(void);
void StartDefaultTask(void *argument);

int main(void)
{
  /* USER CODE BEGIN 1 */

  // #define UART1_BAUDRATE 9600

  // UART1_Init(UART1_BAUDRATE);

  /* USER CODE END 1 */

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */

  /* Init scheduler */
  osKernelInitialize();

  /* Create the thread(s) */
  /* creation of defaultTask */
  defaultTaskHandle = osThreadNew(StartDefaultTask, NULL, &defaultTask_attributes);

  /* Start scheduler */
  osKernelStart();

  /* We should never get here as control is now taken by the scheduler */
  /* Infinite loop */
  while (1)
  {

  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLMUL = RCC_CFGR_PLLMUL12;
  RCC_OscInitStruct.PLL.PREDIV = RCC_CFGR2_PREDIV_DIV2;

  // RCC_OscInitStruct.PLL.PLLSource =

  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }
}

void StartDefaultTask(void *argument)
{
  /* USER CODE BEGIN 5 */

  // Application_Init();

  RCC->AHBENR |= RCC_AHBENR_GPIOCEN;  //Enable clock PORT C
  RCC->AHBENR |= RCC_AHBENR_GPIOAEN;  //Enable clock PORT A
  //-----------------   PWM_En   ----------------------------------
  GPIOA->MODER &= ~GPIO_MODER_MODER0_Msk; //Input mode PA0
  GPIOA->MODER &= ~GPIO_MODER_MODER12_Msk; //Input mode PA12

  //M1_En
  GPIOC->MODER |= GPIO_MODER_MODER9_0;	//General purpose OutPut mode
  GPIOC->OTYPER &= ~GPIO_OTYPER_OT_9;	//PUSH PULL

  // char arr[] = "Hello world";
  /* Infinite loop */
  // volatile uint32_t count = 0;
  Application_Init();

  for(;;) {
    // GPIOC->BSRR |= GPIO_BSRR_BS_9;
    // osDelay(500);
    // GPIOC->BSRR |= GPIO_BSRR_BR_9;
    // osDelay(500);

    // if ((GPIOA->IDR & GPIO_IDR_0) == 1 ) {
    //   count = 0;
    //   USART1_Send_Str(arr);
    //   GPIOC->BSRR |= GPIO_BSRR_BS_9;
    //   osDelay(500);
    // }
    // if ((GPIOA->IDR & GPIO_IDR_12) != 0 ) {
    //   count++;
    //   GPIOC->BSRR |= GPIO_BSRR_BS_9;
    //   osDelay(500);
    // }
    // GPIOC->BSRR |= GPIO_BSRR_BR_9;
  }
  /* USER CODE END 5 */
}

void HAL_TIM_PeriodElapsedCallback(TIM_HandleTypeDef *htim)
{
  if (htim->Instance == TIM1) {
    HAL_IncTick();
  }
}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
